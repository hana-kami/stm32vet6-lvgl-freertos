# Keil uVision project iSO-STM32.uvprojx, settings and files
target 显示BMP (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\ff9;..\..\User\BSP;..\..\FreeRTOS\portable;..\..\FreeRTOS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c test_framework.c
    ../../User/BSP/: bmp_browser.c bsp_bmp.c bsp_exti.c bsp_ili9341_lcd.c bsp_key.c bsp_sdfs_app.c bsp_sdio_sdcard.c bsp_usart.c bsp_usart1.c bsp_xpt2046_lcd.c bsp_gc9b71_lcd.c bsp_lcd.c bsp_st75161_lcd.c
  group ff9
    ../../User/ff9/: diskio.c ff.c
    ../../User/ff9/option/: cc936.c
  group FREERTOS
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/: heap_4.c port.c
software components: CMSIS:CORE 4.1.0
